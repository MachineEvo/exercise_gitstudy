# Keil uVision project UpStanding_Car.uvprojx, settings and files
target UpStanding_Car (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UpStanding_Car +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\OLED;..\HARDWARE\CONTROL;..\HARDWARE\ENCODER;..\HARDWARE\EXTI;..\HARDWARE\MOTOR;..\HARDWARE\PWM;..\HARDWARE\USART3;..\HARDWARE\SENSOR;..\HARDWARE\TRACK
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c main.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c
  group HAREWARE
    ../HARDWARE/MPU6050/: mpuiic.c mpu6050.c mpu6050.h mpuiic.h
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c dmpKey.h dmpmap.h inv_mpu.h inv_mpu_dmp_motion_driver.h
    ../HARDWARE/OLED/: oled.c oled.h oledfont.h
    ../HARDWARE/CONTROL/: control.c control.h
    ../HARDWARE/ENCODER/: encoder.c encoder.h
    ../HARDWARE/EXTI/: exti.c exti.h
    ../HARDWARE/MOTOR/: motor.c motor.h
    ../HARDWARE/PWM/: pwm.c pwm.h
    ../HARDWARE/USART3/: usart3.c usart3.h
    ../HARDWARE/SENSOR/: sensor.h sensor.c
    ../HARDWARE/TRACK/: Track.c Track.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.1.2
